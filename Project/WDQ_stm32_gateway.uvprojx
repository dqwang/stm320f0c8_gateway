# Keil uVision project WDQ_stm32_gateway.uvprojx, settings and files
target stm32f030c8_gateway (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WDQ_stm32_gateway +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\Library\CMSIS;..\Library\STM32F0xx_StdPeriph_Driver\inc;..\Library\STM32F0xx_StdPeriph_Driver\src;..\User;..\Library\CMSIS\Include;..\Library\CMSIS\Device\ST\STM32F0xx\Include;..\User\gateway;..\User\SX1276
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: Drv.c Func.c main.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030.s
    ../User/gateway/: CARD.c DATABASE.c DISP.c FP.c KEYBD.c LOCK.c MOTO.c VOICE.c lora.c
  group STM32F0xx_StdPeriph_Driver
    ../Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SX1276
    ../User/SX1276/: rf.c SX1276.c SX1276_App.c SX1276_Hal.c
